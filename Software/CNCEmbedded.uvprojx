# Keil uVision project CNCEmbedded.uvprojx, settings and files
target STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CNCEmbedded +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x;.\Main;..\Keil_p1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: STM32F10x.s
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MainCode
    ./: main.c
software components: CMSIS:CORE 4.3.0
